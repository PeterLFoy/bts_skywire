# Keil uVision project BTS_Sky_Buf.uvprojx, settings and files
target BTS_Sky_Buf (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: EFM32WG230F256 Silicon Labs
  pack: SiliconLabs.EFM32WG_DFP.5.4.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BTS_Sky_Buf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_EFM32WG990F256 --preinclude=mbed_config.h -DMBEDTLS_CONFIG_HW_SUPPORT -DMBED_BUILD_TIMESTAMP=1517514901.06 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_Silicon_Labs --no_rtti --split_sections -DTARGET_EFM32WG_STK3800 -DDEVICE_I2C_ASYNCH=1 -c -DTARGET_RTOS_M4_M7 -DTARGET_256K -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTINOUT=1 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DTARGET_LIKE_CORTEX_M4 -DEFM32WG990F256 --apcs=interwork -DDEVICE_I2C=1 -DTARGET_CORTEX -DTARGET_SL_AES -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_EFM32WG -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_EFM32 -D__MBED_CMSIS_RTOS_CM -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=4
  c include: .;mbed/.;mbed/TARGET_EFM32WG_STK3800;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/TARGET_EFM32WG_STK3800;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/common;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/emlib;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/emlib/inc;mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/trng;mbed/TARGET_EFM32WG_STK3800/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform;.\ATParser\BufferedSerial\Buffer;.\ATParser\BufferedSerial;.\ATParser
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DEFM32WG990F256,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=4,-DMBEDTLS_CONFIG_HW_SUPPORT
  asm include: .; mbed/.; mbed/TARGET_EFM32WG_STK3800; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/TARGET_EFM32WG_STK3800; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/common; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/emlib; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/emlib/inc; mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/trng; mbed/TARGET_EFM32WG_STK3800/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: mbed/TARGET_EFM32WG_STK3800/TOOLCHAIN_ARM_STD/efm32wg.sct
  link misc: --show_full_path
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_EFM32WG_STK3800/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o dma_api.o em_acmp.o em_adc.o em_aes.o em_assert.o em_burtc.o em_can.o em_cmu.o em_core.o em_cryotimer.o em_crypto.o em_csen.o em_dac.o em_dbg.o em_dma.o em_ebi.o em_emu.o em_gpcrc.o em_gpio.o em_i2c.o em_idac.o em_lcd.o em_ldma.o em_lesense.o em_letimer.o em_leuart.o em_mpu.o em_msc.o em_opamp.o em_pcnt.o em_prs.o em_qspi.o em_rmu.o em_rtc.o em_rtcc.o em_system.o em_timer.o em_usart.o em_vcmp.o em_vdac.o em_wdog.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o pinmap_function.o port_api.o pwmout_api.o rtc_api.o serial_api.o sl_trng.o sleep.o spi_api.o trng_api.o us_ticker.o
    mbed/TARGET_EFM32WG_STK3800/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/common/: clocking.h cmsis.h cmsis_nvic.h CommonPinNames.h device.h objects.h PortNames.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/TARGET_EFM32WG_STK3800/: device_peripherals.h PinNames.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/: dma_api_HAL.h pinmap_function.h rtc_api_HAL.h serial_api_HAL.h sleepmodes.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/: efm32wg230f128.h efm32wg230f256.h efm32wg230f64.h efm32wg232f128.h efm32wg232f256.h efm32wg232f64.h efm32wg280f128.h efm32wg280f256.h efm32wg280f64.h efm32wg290f128.h efm32wg290f256.h efm32wg290f64.h efm32wg295f128.h efm32wg295f256.h efm32wg295f64.h efm32wg330f128.h efm32wg330f256.h efm32wg330f64.h efm32wg332f128.h efm32wg332f256.h efm32wg332f64.h efm32wg360f128.h efm32wg360f256.h efm32wg360f64.h efm32wg380f128.h efm32wg380f256.h efm32wg380f64.h efm32wg390f128.h efm32wg390f256.h efm32wg390f64.h efm32wg395f128.h efm32wg395f256.h efm32wg395f64.h efm32wg840f128.h efm32wg840f256.h efm32wg840f64.h efm32wg842f128.h efm32wg842f256.h efm32wg842f64.h efm32wg880f128.h efm32wg880f256.h efm32wg880f64.h efm32wg890f128.h efm32wg890f256.h efm32wg890f64.h efm32wg895f128.h efm32wg895f256.h efm32wg895f64.h efm32wg900f256.h efm32wg940f128.h efm32wg940f256.h efm32wg940f64.h efm32wg942f128.h efm32wg942f256.h efm32wg942f64.h efm32wg980f128.h efm32wg980f256.h efm32wg980f64.h efm32wg990f128.h efm32wg990f256.h efm32wg990f64.h efm32wg995f128.h efm32wg995f256.h efm32wg995f64.h efm32wg_acmp.h efm32wg_adc.h efm32wg_aes.h efm32wg_af_pins.h efm32wg_af_ports.h efm32wg_burtc.h efm32wg_burtc_ret.h efm32wg_calibrate.h efm32wg_cmu.h efm32wg_dac.h efm32wg_devinfo.h efm32wg_dma.h efm32wg_dma_ch.h efm32wg_dma_descriptor.h efm32wg_dmactrl.h efm32wg_dmareq.h efm32wg_ebi.h efm32wg_emu.h efm32wg_etm.h efm32wg_fpueh.h efm32wg_gpio.h efm32wg_gpio_p.h efm32wg_i2c.h efm32wg_lcd.h efm32wg_lesense.h efm32wg_lesense_buf.h efm32wg_lesense_ch.h efm32wg_lesense_st.h efm32wg_letimer.h efm32wg_leuart.h efm32wg_msc.h efm32wg_pcnt.h efm32wg_prs.h efm32wg_prs_ch.h efm32wg_prs_signals.h efm32wg_rmu.h efm32wg_romtable.h efm32wg_rtc.h efm32wg_timer.h efm32wg_timer_cc.h efm32wg_uart.h efm32wg_usart.h efm32wg_usb.h efm32wg_usb_diep.h efm32wg_usb_doep.h efm32wg_usb_hc.h efm32wg_vcmp.h efm32wg_wdog.h em_device.h system_efm32wg.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_burtc.h em_bus.h em_can.h em_chip.h em_cmu.h em_common.h em_core.h em_cryotimer.h em_crypto.h em_csen.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_idac.h em_lcd.h em_ldma.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_pcnt.h em_prs.h em_qspi.h em_ramfunc.h em_rmu.h em_rtc.h em_rtcc.h em_smu.h em_system.h em_timer.h em_usart.h em_vcmp.h em_vdac.h em_version.h em_wdog.h
    mbed/: mbed.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/: mbed_rtx.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/: PeripheralNames.h PeripheralPins.h
    mbed/TARGET_EFM32WG_STK3800/TARGET_Silicon_Labs/TARGET_EFM32/trng/: sl_trng.h
    ./mbed/TARGET_EFM32WG_STK3800/TOOLCHAIN_ARM_STD/: startup_efm32wg.o system_efm32wg.o
  group Skywire
    ./Skywire/: skywire.cpp skywire.h
    ./ATParser/BufferedSerial/Buffer/: MyBuffer.h MyBuffer.cpp
    ./ATParser/BufferedSerial/: BufferedSerial.h BufferedSerial.cpp
    ./ATParser/: ATParser.h ATParser.cpp
    ./: SKYTSVG.h skytsvg.cpp
  group BTS_Sky_Buf
    ./: mbed_config.h main.cpp
